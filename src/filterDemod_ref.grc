options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: filterDemod_ref
    output_language: python
    run_options: run
  states: {}

blocks:
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: source_file
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: save_file
    samp_rate: samp_rate
  states: {}
- name: cutoff_freq
  id: parameter
  parameters:
    label: cutoff_freq
    type: intx
    value: '80000'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: decimation
    type: intx
    value: '1'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: gain
    type: intx
    value: '1'
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: decimation
    gain: gain
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: intx
    value: '2000000'
  states: {}
- name: save_file
  id: parameter
  parameters:
    label: save_file
    type: str
    value: ''
  states: {}
- name: source_file
  id: parameter
  parameters:
    label: source_file
    type: str
    value: ''
  states: {}
- name: trans_width
  id: parameter
  parameters:
    label: trans_width
    type: intx
    value: '2000'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0_1, '0']
- [low_pass_filter_0_1, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
